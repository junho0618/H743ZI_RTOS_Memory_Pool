<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\06_H743ZI_RTOS_Memory_Pool.ewp</path>
  </project>
  <batchBuild />
</workspace>
